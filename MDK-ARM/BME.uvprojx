# Keil uVision project BME.uvprojx, settings and files
target BME (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BME +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_PRESENT=1U
  c include: ../Core/Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;          ../Drivers/CMSIS/Include;          ../Drivers/CMSIS/DSP/Include;          ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: ssd1306.c max30102.c max30102_driver.c max30102_baseline.c max30102_spo2.c max30102_bpm.c max30102_algo_utils.c app_display.c app_settings.c app_measurement.c app_bpm_filter.c app_oxy_status.c app_ppg_signal.c app_ppg_pulse.c app_ppg_sqi.c app_hrv.c app_rr.c app_spo2_filter.c app_motion.c app_protocol.c eeprom_driver.c eeprom_store.c eeprom_cmd.c app_sd_card.c sd_diskio.c app_data_log.c app_runtime.c app_diag.c app_sd_file.c app_ecg.c app_ptt.c main.c gpio.c freertos.c adc.c dma.c i2c.c iwdg.c rtc.c sdio.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: unicode.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CMSIS-DSP/CommonTables
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
  group CMSIS-DSP/Filtering
    ../Drivers/CMSIS/DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_init_f32.c
  group CMSIS-DSP/Transform
    ../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_cfft_f32.c arm_cfft_radix8_f32.c
  group CMSIS-DSP/FastMath
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c
  group CMSIS-DSP/Statistics
    ../Drivers/CMSIS/DSP/Source/StatisticsFunctions/: arm_rms_f32.c arm_max_f32.c arm_min_f32.c arm_mean_f32.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 6.2.0
